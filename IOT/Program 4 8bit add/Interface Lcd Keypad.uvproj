# Keil uVision project Interface Lcd Keypad.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051 Cadence Design Systems Inc.
  cpu: IRAM(0-0x7F)  CLOCK(12000000) MODC2
  output: Interface Lcd Keypad
  c flags: Optimize=8 SizeSpeed=1
